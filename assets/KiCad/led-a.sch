File: assets/KiCad/led-a.sch (KiCad schematic (older format))
At the start: 256 parts

Commit message: update schematics
Parts:
- gave numbers to parts that had none: 256
